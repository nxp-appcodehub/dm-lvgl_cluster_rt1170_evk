# IAR project lvgl_guider_cm7.ewp, settings and files
configuration flexspi_nor_sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=0; XIP_BOOT_HEADER_XMCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm7; LV_CONF_INCLUDE_SIMPLE=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; VG_COMMAND_CALL=1; VG_TARGET_FAST_CLEAR=0; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; SERIAL_PORT_TYPE_USBCDC; PRINTF_ADVANCED_ENABLE; SERIAL_PORT_TYPE_UART; OSA_USED; FSL_OSA_TASK_ENABLE; USB_CDC_SERIAL_MANAGER_RUN_NO_HOST
  ICCARM.CCDiagSuppress: Pa089,Go029,Pe188,Pe111,Pe236,Pe546
  ICCARM.IExtraOptions: --diag_suppress Pa082,Pa050
  ICCARM.CCIncludePath2: ../Core/board; ../Core/source; ../Core/CMSIS; ../Core/component/lists; ../Core/component/serial_manager; ../Core/component/silicon_id; ../Core/component/uart; ../../custom; ../Core/device; ../Core/drivers; ../Core/freertos/freertos_kernel/include; ../Core/freertos/freertos_kernel/portable/IAR/ARM_CM4F; ../../generated; ../../generated/guider_customer_fonts; ../../generated/guider_fonts; ../Core/lvgl; ../Core/lvgl/lvgl; ../Core/lvgl/lvgl/src; ../Core/lvgl/lvgl/src/font; ../Core/touchpanel; ../Core/utilities; ../Core/vglite/VGLite/rtos; ../Core/vglite/VGLiteKernel; ../Core/vglite/VGLiteKernel/rtos; ../Core/vglite/font; ../Core/vglite/font/mcufont/decoder; ../Core/vglite/inc; ../Core/video; ../Core/xip; ..\Core\component\osa; ..\Core\middleware\usb\device; ..\Core\middleware\usb\include; ..\Core\middleware\usb\phy; ..\Core\source\log; ..\Core\source\shell; ..\Core\source\syscmd; ..\Core\source\usb; ..\Core\component\serial_manager\usb_cdc_adapter
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ../Core/source
  OBJCOPY.OOCOutputFile: lvgl_guider_cm7.bin
  ILINK.IlinkOutputFile: lvgl_guider_cm7.out
  ILINK.IlinkIcfFile: MIMXRT1176/iar/MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=0; XIP_BOOT_HEADER_XMCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; LV_CONF_INCLUDE_SIMPLE=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; VG_COMMAND_CALL=1; VG_TARGET_FAST_CLEAR=0; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; MCUXPRESSO_SDK; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; SERIAL_PORT_TYPE_USBCDC; PRINTF_ADVANCED_ENABLE; SERIAL_PORT_TYPE_UART; OSA_USED; FSL_OSA_TASK_ENABLE; USB_CDC_SERIAL_MANAGER_RUN_NO_HOST
  ICCARM.CCIncludePath2: ../Core/board; ../Core/source; ../Core/CMSIS; ../Core/component/lists; ../Core/component/serial_manager; ../Core/component/silicon_id; ../Core/component/uart; ../../custom; ../Core/device; ../Core/drivers; ../Core/freertos/freertos_kernel/include; ../Core/freertos/freertos_kernel/portable/IAR/ARM_CM4F; ../../generated; ../../generated/guider_customer_fonts; ../../generated/guider_fonts; ../Core/lvgl; ../Core/lvgl/lvgl; ../Core/lvgl/lvgl/src; ../Core/lvgl/lvgl/src/font; ../Core/touchpanel; ../Core/utilities; ../Core/vglite/VGLite/rtos; ../Core/vglite/VGLiteKernel; ../Core/vglite/VGLiteKernel/rtos; ../Core/vglite/font; ../Core/vglite/font/mcufont/decoder; ../Core/vglite/inc; ../Core/video; ../Core/xip; ..\Core\source\usb; ..\Core\middleware\usb\device; ..\Core\middleware\usb\include; ..\Core\middleware\usb\phy; ..\Core\source\shell; ..\Core\component\osa; ..\Core\source\syscmd; ..\Core\source\log; ..\Core\component\serial_manager\usb_cdc_adapter
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: lvgl_guider_cm7_release.bin
  group board
    ../Core/board/: board.c board.h clock_config.c clock_config.h dcd.c dcd.h display_support.c display_support.h lvgl_support.c lvgl_support.h pin_mux.c pin_mux.h xmcd.c xmcd.h
  group CMSIS
    ../Core/CMSIS/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/lists
    ../Core/component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/osa
    ../Core/component/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction_free_rtos.h
  group component/serial_manager
    ../Core/component/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_port_uart.c fsl_component_serial_port_uart.h fsl_component_serial_port_usb.c fsl_component_serial_port_usb.h
  group component/serial_manager/usb_cdc_adapter
    ../Core/component/serial_manager/usb_cdc_adapter/: usb_device_descriptor.c usb_device_descriptor.h
  group component/silicon_id
    ../Core/component/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
  group component/uart
    ../Core/component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group custom
    ../../custom/: custom.c custom.h custom.mk
  group device
    ../Core/device/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group doc
    ../Core/doc/: readme.txt
  group drivers
    ../Core/drivers/: fsl_anatop_ai.c fsl_anatop_ai.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_elcdif.c fsl_elcdif.h fsl_gpio.c fsl_gpio.h fsl_gpt.c fsl_gpt.h fsl_iomuxc.h fsl_lcdifv2.c fsl_lcdifv2.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_memory.h fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_pmu.c fsl_pmu.h fsl_pxp.c fsl_pxp.h fsl_snvs_hp.c fsl_snvs_hp.h fsl_soc_mipi_csi2rx.c fsl_soc_mipi_csi2rx.h fsl_soc_src.c fsl_soc_src.h
  group freertos/freertos_kernel
    ../Core/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    ../Core/freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group freertos/freertos_kernel/portable
    ../Core/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../Core/freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/portable/MemMang
    ../Core/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group generated
    ../../generated/: events_init.c events_init.h gui_guider.c gui_guider.h setup_scr_Logo_Screen.c setup_scr_screen.c
  group generated/guider_customer_fonts
    ../../generated/guider_customer_fonts/: guider_customer_fonts.h
  group generated/guider_fonts
    ../../generated/guider_fonts/: guider_fonts.h lv_font_Abel_regular_70.c lv_font_Abel_regular_90.c lv_font_Alatsi_Regular_20.c lv_font_montserratMedium_20.c lv_font_simsun_12.c
  group generated/images
    ../../generated/images/: _0_15x27.c _10_27x26.c _12_26x27.c _14_29x27.c _16_27x27.c _2_15x26.c _4_17x26.c _6_14x27.c _8_16x27.c _auto_start_70x70.c _bearing2_143x107.c _car_180x220.c _compass_110x110.c _compass_pointer_14x12.c _div_229x4.c _frame2px_721x324.c _gas_gauge_135x57.c _left_1_49x46.c _left_2_39x39.c _left_3_26x26.c _lichengshu_178x37.c _light_ABS_44x32.c _light_ABSOn_44x32.c _light_battery_45x30.c _light_batteryOn_45x30.c _light_brake_37x38.c _light_brakeOn_37x38.c _light_engine_39x25.c _light_engineOn_39x25.c _light_highbeam_42x26.c _light_highbeamOn_42x26.c _light_oil_52x20.c _light_oilOn_52x20.c _mid_1_60x26.c _mid_2_48x22.c _mid_3_33x17.c _NXP_LOGO_400x200.c _odo_178x37.c _oil_gauge_135x56.c _outer2px_1_73x28.c _outer2px_2_58x59.c _outer2px_3_28x73.c _outer2px_4_28x73.c _outer2px_5_58x59.c _outer2px_6_73x28.c _outer2px_7_73x28.c _outer2px_8_58x59.c _panel_1_png_102x49.c _panel_2_png_76x57.c _right_1_48x44.c _right_2_34x33.c _right_3_24x27.c _RPMx1000_42x34.c _shengyu_200x37.c _signal_left_48x40.c _signal_leftOn_48x40.c _signal_right_48x40.c _signal_rightOn_48x40.c _temp_scale_137x57.c _tick10_16x21.c _tick11_17x20.c _tick12_17x21.c _tick13_18x20.c _tick14_18x20.c _tick15_19x19.c _tick16_19x19.c _tick17_20x19.c _tick18_20x19.c _tick19_21x17.c _tick1_9x20.c _tick20_21x17.c _tick21_21x16.c _tick22_21x16.c _tick23_21x15.c _tick24_21x14.c _tick25_21x13.c _tick26_21x12.c _tick27_21x12.c _tick28_21x10.c _tick29_21x10.c _tick2_9x20.c _tick30_20x9.c _tick31_19x9.c _tick32_20x9.c _tick33_21x10.c _tick34_21x11.c _tick35_21x12.c _tick36_21x13.c _tick37_21x14.c _tick38_21x15.c _tick39_21x16.c _tick3_10x21.c _tick40_21x16.c _tick41_21x17.c _tick42_21x17.c _tick43_21x18.c _tick44_20x18.c _tick45_20x19.c _tick46_19x19.c _tick47_19x20.c _tick48_18x20.c _tick49_18x21.c _tick4_11x21.c _tick50_17x21.c _tick51_17x21.c _tick52_16x21.c _tick53_16x21.c _tick54_15x21.c _tick55_14x21.c _tick56_13x21.c _tick57_12x21.c _tick58_11x21.c _tick59_10x21.c _tick5_12x21.c _tick60_9x20.c _tick61_9x19.c _tick62_9x20.c _tick63_10x21.c _tick64_10x21.c _tick65_12x21.c _tick66_12x21.c _tick67_13x21.c _tick68_14x21.c _tick69_15x21.c _tick6_13x21.c _tick70_16x21.c _tick71_16x21.c _tick72_17x21.c _tick73_17x21.c _tick74_19x20.c _tick75_19x20.c _tick76_19x19.c _tick77_19x19.c _tick78_20x18.c _tick79_20x18.c _tick7_14x21.c _tick80_21x17.c _tick81_20x17.c _tick8_15x21.c _tick9_16x21.c _tick_glow_363x387.c _ticks_base_346x369.c _trip_200x37.c
  group lvgl
    ../Core/lvgl/: ChangeLogKSDK.txt
  group lvgl/lvgl
    ../Core/lvgl/lvgl/: LICENCE.txt lvgl.h
  group lvgl/lvgl/src
    ../Core/lvgl/lvgl/src/: lv_api_map.h lv_conf_internal.h lv_conf_kconfig.h lvgl.h
  group lvgl/lvgl/src/core
    ../Core/lvgl/lvgl/src/core/: lv_disp.c lv_disp.h lv_event.c lv_event.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_indev_scroll.c lv_indev_scroll.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_draw.c lv_obj_draw.h lv_obj_pos.c lv_obj_pos.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_tree.c lv_obj_tree.h lv_refr.c lv_refr.h lv_theme.c lv_theme.h
  group lvgl/lvgl/src/draw
    ../Core/lvgl/lvgl/src/draw/: lv_draw.c lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_rect.c lv_draw_rect.h lv_draw_triangle.c lv_draw_triangle.h lv_img_buf.c lv_img_buf.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h
  group lvgl/lvgl/src/draw/nxp
    ../Core/lvgl/lvgl/src/draw/nxp/: lv_gpu_nxp.c lv_gpu_nxp.h
  group lvgl/lvgl/src/draw/nxp/pxp
    ../Core/lvgl/lvgl/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_draw_pxp_blend.h lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp.h lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp_osa.h
  group lvgl/lvgl/src/draw/nxp/vglite
    ../Core/lvgl/lvgl/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_arc.h lv_draw_vglite_blend.c lv_draw_vglite_blend.h lv_draw_vglite_rect.c lv_draw_vglite_rect.h lv_gpu_nxp_vglite.c lv_gpu_nxp_vglite.h
  group lvgl/lvgl/src/draw/sdl
    ../Core/lvgl/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl.h lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_composite.h lv_draw_sdl_img.c lv_draw_sdl_img.h lv_draw_sdl_label.c lv_draw_sdl_mask.c lv_draw_sdl_mask.h lv_draw_sdl_polygon.c lv_draw_sdl_priv.h lv_draw_sdl_rect.c lv_draw_sdl_rect.h lv_draw_sdl_stack_blur.c lv_draw_sdl_stack_blur.h lv_draw_sdl_texture_cache.c lv_draw_sdl_texture_cache.h lv_draw_sdl_utils.c lv_draw_sdl_utils.h
  group lvgl/lvgl/src/draw/stm32_dma2d
    ../Core/lvgl/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c lv_gpu_stm32_dma2d.h
  group lvgl/lvgl/src/draw/sw
    ../Core/lvgl/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw.h lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_blend.h lv_draw_sw_dither.c lv_draw_sw_dither.h lv_draw_sw_gradient.c lv_draw_sw_gradient.h lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
  group lvgl/lvgl/src/extra
    ../Core/lvgl/lvgl/src/extra/: lv_extra.c lv_extra.h
  group lvgl/lvgl/src/extra/layouts
    ../Core/lvgl/lvgl/src/extra/layouts/: lv_layouts.h
  group lvgl/lvgl/src/extra/layouts/flex
    ../Core/lvgl/lvgl/src/extra/layouts/flex/: lv_flex.c lv_flex.h
  group lvgl/lvgl/src/extra/layouts/grid
    ../Core/lvgl/lvgl/src/extra/layouts/grid/: lv_grid.c lv_grid.h
  group lvgl/lvgl/src/extra/libs
    ../Core/lvgl/lvgl/src/extra/libs/: lv_libs.h
  group lvgl/lvgl/src/extra/libs/bmp
    ../Core/lvgl/lvgl/src/extra/libs/bmp/: lv_bmp.c lv_bmp.h
  group lvgl/lvgl/src/extra/libs/ffmpeg
    ../Core/lvgl/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c lv_ffmpeg.h
  group lvgl/lvgl/src/extra/libs/freetype
    ../Core/lvgl/lvgl/src/extra/libs/freetype/: lv_freetype.c lv_freetype.h
  group lvgl/lvgl/src/extra/libs/fsdrv
    ../Core/lvgl/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c lv_fsdrv.h
  group lvgl/lvgl/src/extra/libs/gif
    ../Core/lvgl/lvgl/src/extra/libs/gif/: gifdec.c gifdec.h lv_gif.c lv_gif.h
  group lvgl/lvgl/src/extra/libs/png
    ../Core/lvgl/lvgl/src/extra/libs/png/: lodepng.c lodepng.h lv_png.c lv_png.h
  group lvgl/lvgl/src/extra/libs/qrcode
    ../Core/lvgl/lvgl/src/extra/libs/qrcode/: lv_qrcode.c lv_qrcode.h qrcodegen.c qrcodegen.h
  group lvgl/lvgl/src/extra/libs/rlottie
    ../Core/lvgl/lvgl/src/extra/libs/rlottie/: lv_rlottie.c lv_rlottie.h
  group lvgl/lvgl/src/extra/libs/sjpg
    ../Core/lvgl/lvgl/src/extra/libs/sjpg/: lv_sjpg.c lv_sjpg.h tjpgd.c tjpgd.h tjpgdcnf.h
  group lvgl/lvgl/src/extra/others
    ../Core/lvgl/lvgl/src/extra/others/: lv_others.h
  group lvgl/lvgl/src/extra/others/gridnav
    ../Core/lvgl/lvgl/src/extra/others/gridnav/: lv_gridnav.c lv_gridnav.h
  group lvgl/lvgl/src/extra/others/monkey
    ../Core/lvgl/lvgl/src/extra/others/monkey/: lv_monkey.c lv_monkey.h
  group lvgl/lvgl/src/extra/others/snapshot
    ../Core/lvgl/lvgl/src/extra/others/snapshot/: lv_snapshot.c lv_snapshot.h
  group lvgl/lvgl/src/extra/themes
    ../Core/lvgl/lvgl/src/extra/themes/: lv_themes.h
  group lvgl/lvgl/src/extra/themes/basic
    ../Core/lvgl/lvgl/src/extra/themes/basic/: lv_theme_basic.c lv_theme_basic.h
  group lvgl/lvgl/src/extra/themes/default
    ../Core/lvgl/lvgl/src/extra/themes/default/: lv_theme_default.c lv_theme_default.h
  group lvgl/lvgl/src/extra/themes/mono
    ../Core/lvgl/lvgl/src/extra/themes/mono/: lv_theme_mono.c lv_theme_mono.h
  group lvgl/lvgl/src/extra/widgets
    ../Core/lvgl/lvgl/src/extra/widgets/: lv_widgets.h
  group lvgl/lvgl/src/extra/widgets/analogclock
    ../Core/lvgl/lvgl/src/extra/widgets/analogclock/: lv_analogclock.c lv_analogclock.h
  group lvgl/lvgl/src/extra/widgets/animimg
    ../Core/lvgl/lvgl/src/extra/widgets/animimg/: lv_animimg.c lv_animimg.h
  group lvgl/lvgl/src/extra/widgets/calendar
    ../Core/lvgl/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar.h lv_calendar_header_arrow.c lv_calendar_header_arrow.h lv_calendar_header_dropdown.c lv_calendar_header_dropdown.h
  group lvgl/lvgl/src/extra/widgets/carousel
    ../Core/lvgl/lvgl/src/extra/widgets/carousel/: lv_carousel.c lv_carousel.h
  group lvgl/lvgl/src/extra/widgets/chart
    ../Core/lvgl/lvgl/src/extra/widgets/chart/: lv_chart.c lv_chart.h
  group lvgl/lvgl/src/extra/widgets/colorwheel
    ../Core/lvgl/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c lv_colorwheel.h
  group lvgl/lvgl/src/extra/widgets/dclock
    ../Core/lvgl/lvgl/src/extra/widgets/dclock/: lv_dclock.c lv_dclock.h
  group lvgl/lvgl/src/extra/widgets/imgbtn
    ../Core/lvgl/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c lv_imgbtn.h
  group lvgl/lvgl/src/extra/widgets/keyboard
    ../Core/lvgl/lvgl/src/extra/widgets/keyboard/: chinese_library.h lv_keyboard.c lv_keyboard.h lv_zh_keyboard.c lv_zh_keyboard.h
  group lvgl/lvgl/src/extra/widgets/led
    ../Core/lvgl/lvgl/src/extra/widgets/led/: lv_led.c lv_led.h
  group lvgl/lvgl/src/extra/widgets/list
    ../Core/lvgl/lvgl/src/extra/widgets/list/: lv_list.c lv_list.h
  group lvgl/lvgl/src/extra/widgets/menu
    ../Core/lvgl/lvgl/src/extra/widgets/menu/: lv_menu.c lv_menu.h
  group lvgl/lvgl/src/extra/widgets/meter
    ../Core/lvgl/lvgl/src/extra/widgets/meter/: lv_meter.c lv_meter.h
  group lvgl/lvgl/src/extra/widgets/msgbox
    ../Core/lvgl/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c lv_msgbox.h
  group lvgl/lvgl/src/extra/widgets/radiobtn
    ../Core/lvgl/lvgl/src/extra/widgets/radiobtn/: lv_radiobtn.c lv_radiobtn.h
  group lvgl/lvgl/src/extra/widgets/span
    ../Core/lvgl/lvgl/src/extra/widgets/span/: lv_span.c lv_span.h
  group lvgl/lvgl/src/extra/widgets/spinbox
    ../Core/lvgl/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c lv_spinbox.h
  group lvgl/lvgl/src/extra/widgets/spinner
    ../Core/lvgl/lvgl/src/extra/widgets/spinner/: lv_spinner.c lv_spinner.h
  group lvgl/lvgl/src/extra/widgets/tabview
    ../Core/lvgl/lvgl/src/extra/widgets/tabview/: lv_tabview.c lv_tabview.h
  group lvgl/lvgl/src/extra/widgets/tileview
    ../Core/lvgl/lvgl/src/extra/widgets/tileview/: lv_tileview.c lv_tileview.h
  group lvgl/lvgl/src/extra/widgets/win
    ../Core/lvgl/lvgl/src/extra/widgets/win/: lv_win.c lv_win.h
  group lvgl/lvgl/src/font
    ../Core/lvgl/lvgl/src/font/: lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_loader.c lv_font_loader.h lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_symbol_def.h
  group lvgl/lvgl/src/hal
    ../Core/lvgl/lvgl/src/hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group lvgl/lvgl/src/misc
    ../Core/lvgl/lvgl/src/misc/: lv_anim.c lv_anim.h lv_anim_timeline.c lv_anim_timeline.h lv_area.c lv_area.h lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_color.c lv_color.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_lru.c lv_lru.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_printf.c lv_printf.h lv_style.c lv_style.h lv_style_gen.c lv_style_gen.h lv_templ.c lv_templ.h lv_timer.c lv_timer.h lv_tlsf.c lv_tlsf.h lv_txt.c lv_txt.h lv_txt_ap.c lv_txt_ap.h lv_types.h lv_utils.c lv_utils.h
  group lvgl/lvgl/src/widgets
    ../Core/lvgl/lvgl/src/widgets/: lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnmatrix.c lv_btnmatrix.h lv_canvas.c lv_canvas.h lv_checkbox.c lv_checkbox.h lv_dropdown.c lv_dropdown.h lv_img.c lv_img.h lv_label.c lv_label.h lv_line.c lv_line.h lv_objx_templ.c lv_objx_templ.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_switch.c lv_switch.h lv_table.c lv_table.h lv_textarea.c lv_textarea.h
  group middleware/usb/device
    ../Core/middleware/usb/device/: usb_device.h usb_device_dci.c usb_device_dci.h usb_device_ehci.c usb_device_ehci.h
  group middleware/usb/include
    ../Core/middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group middleware/usb/phy
    ../Core/middleware/usb/phy/: usb_phy.c usb_phy.h
  group MIMXRT1176/iar
    MIMXRT1176/iar/: evkmimxrt1170_connect_cm4_cm7side.jlinkscript evkmimxrt1170_connect_cm7.mac MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
  group source
    ../Core/source/: appconfig.h FreeRTOSConfig.h lv_conf.h lvgl_guider.c rtc_update.c rtc_update.h
  group source/log
    ../Core/source/log/: logging.c logging.h
  group source/shell
    ../Core/source/shell/: shell.c shell_color.h
  group source/syscmd
    ../Core/source/syscmd/: syscmd.c syscmd.h
  group source/usb
    ../Core/source/usb/: usb_device_cdc_acm.c usb_device_cdc_acm.h usb_device_ch9.c usb_device_ch9.h usb_device_class.c usb_device_class.h usb_device_config.h
  group startup
    startup/: startup_MIMXRT1176_cm7.s
  group touchpanel
    ../Core/touchpanel/: fsl_gt911.c fsl_gt911.h
  group utilities
    ../Core/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_shell.c fsl_shell.h fsl_str.c fsl_str.h
  group vglite
    ../Core/vglite/: ChangeLogKSDK.txt LICENSE.txt
  group vglite/font
    ../Core/vglite/font/: buf_reader.c buf_reader.h fonts.h rle_font_read.c vft_debug.c vft_debug.h vft_draw.c vft_draw.h vg_lite_text.c
  group vglite/font/mcufont
    ../Core/vglite/font/mcufont/: LICENSE
  group vglite/font/mcufont/decoder
    ../Core/vglite/font/mcufont/decoder/: mcufont.h mf_bwfont.c mf_bwfont.h mf_config.h mf_encoding.c mf_encoding.h mf_font.c mf_font.h mf_justify.c mf_justify.h mf_kerning.c mf_kerning.h mf_rlefont.c mf_rlefont.h mf_scaledfont.c mf_scaledfont.h mf_wordwrap.c mf_wordwrap.h
  group vglite/inc
    ../Core/vglite/inc/: vg_lite.h vg_lite_hal.h vg_lite_text.h
  group vglite/VGLite
    ../Core/vglite/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c
  group vglite/VGLite/rtos
    ../Core/vglite/VGLite/rtos/: vg_lite_os.c vg_lite_os.h
  group vglite/VGLiteKernel
    ../Core/vglite/VGLiteKernel/: vg_lite_hw.h vg_lite_kernel.c vg_lite_kernel.h
  group vglite/VGLiteKernel/rtos
    ../Core/vglite/VGLiteKernel/rtos/: vg_lite_hal.c vg_lite_platform.h
  group video
    ../Core/video/: fsl_dc_fb.h fsl_dc_fb_elcdif.c fsl_dc_fb_elcdif.h fsl_dc_fb_lcdifv2.c fsl_dc_fb_lcdifv2.h fsl_display.h fsl_hx8394.c fsl_hx8394.h fsl_mipi_dsi_cmd.c fsl_mipi_dsi_cmd.h fsl_rm68191.c fsl_rm68191.h fsl_rm68200.c fsl_rm68200.h fsl_video_common.c fsl_video_common.h
  group xip
    ../Core/xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
