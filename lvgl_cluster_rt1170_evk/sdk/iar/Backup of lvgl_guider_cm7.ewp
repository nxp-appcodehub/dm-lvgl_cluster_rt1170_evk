# IAR project Backup of lvgl_guider_cm7.ewp, settings and files
configuration flexspi_nor_sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=0; XIP_BOOT_HEADER_XMCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm7; LV_CONF_INCLUDE_SIMPLE=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; VG_COMMAND_CALL=1; VG_TARGET_FAST_CLEAR=0; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa089,Go029,Pe188,Pe111,Pe236,Pe546
  ICCARM.IExtraOptions: --diag_suppress Pa082,Pa050
  ICCARM.CCIncludePath2: ../Core/board; ../Core/source; ../Core/CMSIS; ../Core/component/lists; ../Core/component/serial_manager; ../Core/component/silicon_id; ../Core/component/uart; ../../custom; ../Core/device; ../Core/drivers; ../Core/freertos/freertos_kernel/include; ../Core/freertos/freertos_kernel/portable/IAR/ARM_CM4F; ../../generated; ../../generated/guider_customer_fonts; ../../generated/guider_fonts; ../Core/lvgl; ../Core/lvgl/lvgl; ../Core/lvgl/lvgl/src; ../Core/lvgl/lvgl/src/font; ../Core/touchpanel; ../Core/utilities; ../Core/vglite/VGLite/rtos; ../Core/vglite/VGLiteKernel; ../Core/vglite/VGLiteKernel/rtos; ../Core/vglite/font; ../Core/vglite/font/mcufont/decoder; ../Core/vglite/inc; ../Core/video; ../Core/xip
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ../Core/source
  ILINK.IlinkOutputFile: lvgl_guider_cm7.out
  ILINK.IlinkIcfFile: MIMXRT1176/iar/MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=0; XIP_BOOT_HEADER_XMCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; LV_CONF_INCLUDE_SIMPLE=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; VG_COMMAND_CALL=1; VG_TARGET_FAST_CLEAR=0; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; MCUXPRESSO_SDK
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../Core/board/: board.c board.h clock_config.c clock_config.h dcd.c dcd.h display_support.c display_support.h lvgl_support.c lvgl_support.h pin_mux.c pin_mux.h xmcd.c xmcd.h
  group CMSIS
    ../Core/CMSIS/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/lists
    ../Core/component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/serial_manager
    ../Core/component/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_port_uart.c fsl_component_serial_port_uart.h
  group component/silicon_id
    ../Core/component/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
  group component/uart
    ../Core/component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group custom
    ../../custom/: custom.c custom.h custom.mk
  group device
    ../Core/device/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group doc
    ../Core/doc/: readme.txt
  group drivers
    ../Core/drivers/: fsl_anatop_ai.c fsl_anatop_ai.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_elcdif.c fsl_elcdif.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lcdifv2.c fsl_lcdifv2.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_memory.h fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_pmu.c fsl_pmu.h fsl_pxp.c fsl_pxp.h fsl_soc_mipi_csi2rx.c fsl_soc_mipi_csi2rx.h fsl_soc_src.c fsl_soc_src.h
  group freertos/freertos_kernel
    ../Core/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    ../Core/freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group freertos/freertos_kernel/portable
    ../Core/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../Core/freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/portable/MemMang
    ../Core/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group generated
    ../../generated/: events_init.c events_init.h generated.mk guider_lv_conf.h gui_guider.c gui_guider.h gui_guider.py setup_scr_screen.c setup_scr_screen_2.c
  group generated/guider_customer_fonts
    ../../generated/guider_customer_fonts/: guider_customer_fonts.h guider_customer_fonts.mk
  group generated/guider_fonts
    ../../generated/guider_fonts/: guider_fonts.h guider_fonts.mk lv_font_Abel_regular_70.c lv_font_Abel_regular_90.c lv_font_montserratMedium_20.c lv_font_simsun_12.c
  group generated/images
    ../../generated/images/: images.mk _0_15x27.c _10_27x26.c _12_26x27.c _14_29x27.c _16_27x27.c _2_15x26.c _4_17x26.c _6_14x27.c _8_16x27.c _auto_start_70x70.c _car_180x220.c _compass_110x110.c _compass_pointer_14x12.c _div_229x4.c _frame2px_721x324.c _left_1_49x46.c _left_2_39x39.c _left_3_26x26.c _lichengshu_178x37.c _light_ABSOn_44x32.c _light_ABS_44x32.c _light_batteryOn_45x30.c _light_battery_45x30.c _light_brakeOn_37x38.c _light_brake_37x38.c _light_engineOn_39x25.c _light_engine_39x25.c _light_highbeamOn_42x26.c _light_highbeam_42x26.c _light_oilOn_52x20.c _light_oil_52x20.c _mid_1_60x26.c _mid_2_48x22.c _mid_3_33x17.c _oil_gauge_135x56.c _outer2px_1_73x28.c _outer2px_2_58x59.c _outer2px_3_28x73.c _outer2px_4_28x73.c _outer2px_5_58x59.c _outer2px_6_73x28.c _outer2px_7_73x28.c _outer2px_8_58x59.c _panel_1_png_102x49.c _panel_2_png_76x57.c _panel_4_png_100x100.c _right_1_48x44.c _right_2_34x33.c _right_3_24x27.c _RPMx1000_42x34.c _shengyu_200x37.c _signal_leftOn_48x40.c _signal_left_48x40.c _signal_rightOn_48x40.c _signal_right_48x40.c _temp_scale_137x57.c _tick10_16x21.c _tick11_17x20.c _tick12_17x21.c _tick13_18x20.c _tick14_18x20.c _tick15_19x19.c _tick16_19x19.c _tick17_20x19.c _tick18_20x19.c _tick19_21x17.c _tick1_9x20.c _tick20_21x17.c _tick21_21x16.c _tick22_21x16.c _tick23_21x15.c _tick24_21x14.c _tick25_21x13.c _tick26_21x12.c _tick27_21x12.c _tick28_21x10.c _tick29_21x10.c _tick2_9x20.c _tick30_20x9.c _tick31_19x9.c _tick32_20x9.c _tick33_21x10.c _tick34_21x11.c _tick35_21x12.c _tick36_21x13.c _tick37_21x14.c _tick38_21x15.c _tick39_21x16.c _tick3_10x21.c _tick40_21x16.c _tick41_21x17.c _tick42_21x17.c _tick43_21x18.c _tick44_20x18.c _tick45_20x19.c _tick46_19x19.c _tick47_19x20.c _tick48_18x20.c _tick49_18x21.c _tick4_11x21.c _tick50_17x21.c _tick51_17x21.c _tick52_16x21.c _tick53_16x21.c _tick54_15x21.c _tick55_14x21.c _tick56_13x21.c _tick57_12x21.c _tick58_11x21.c _tick59_10x21.c _tick5_12x21.c _tick60_9x20.c _tick61_9x19.c _tick62_9x20.c _tick63_10x21.c _tick64_10x21.c _tick65_12x21.c _tick66_12x21.c _tick67_13x21.c _tick68_14x21.c _tick69_15x21.c _tick6_13x21.c _tick70_16x21.c _tick71_16x21.c _tick72_17x21.c _tick73_17x21.c _tick74_19x20.c _tick75_19x20.c _tick76_19x19.c _tick77_19x19.c _tick78_20x18.c _tick79_20x18.c _tick7_14x21.c _tick80_21x17.c _tick81_20x17.c _tick8_15x21.c _tick9_16x21.c _ticks_base_346x369.c _tick_glow_363x387.c
  group generated/mPythonImages
    ../../generated/mPythonImages/: mp-1000596593.png mp-1000908995.png mp-1003328184.png mp-1003944662.png mp-1018681196.png mp-1031814307.png mp-1057022541.png mp-1066170385.png mp-1068735169.png mp-1072849168.png mp-1077035273.png mp-1079105589.png mp-1080245715.png mp-108874353.png mp-1097522010.png mp-1119806597.png mp-1143565327.png mp-1145925749.png mp-115745081.png mp-1158324826.png mp-1158719284.png mp-1167727759.png mp-1177341007.png mp-1183033964.png mp-1186012036.png mp-1186813350.png mp-1191423022.png mp-1210609045.png mp-1217143601.png mp-1234442616.png mp-1234877626.png mp-1247193075.png mp-1252144323.png mp-1268602371.png mp-1271323393.png mp-1272631060.png mp-1274646777.png mp-1282134635.png mp-1311521438.png mp-1312068206.png mp-1332044591.png mp-1332616432.png mp-1333828334.png mp-1333870216.png mp-1348513973.png mp-136148337.png mp-1381128320.png mp-1383197507.png mp-1397366277.png mp-1406963283.png mp-1412586777.png mp-1416374007.png mp-1418241766.png mp-1442088893.png mp-14455603.png mp-1447740110.png mp-1448624925.png mp-1460724307.png mp-1492886476.png mp-1502742436.png mp-151186717.png mp-1519040384.png mp-1541884400.png mp-1550387513.png mp-1553783728.png mp-1560628518.png mp-1578371866.png mp-1584620631.png mp-1598156376.png mp-1637819098.png mp-1646843149.png mp-1674058015.png mp-1677000595.png mp-1724033729.png mp-1733418128.png mp-1735737568.png mp-1753149169.png mp-1755509591.png mp-1764298833.png mp-1782383436.png mp-1801837085.png mp-1802774150.png mp-1803005235.png mp-1827656863.png mp-1829872625.png mp-1833685852.png mp-1834232607.png mp-1837770865.png mp-1842807829.png mp-1843947955.png mp-1854239419.png mp-186031216.png mp-1886610751.png mp-1893230655.png mp-1901240653.png mp-1909911682.png mp-1930536238.png mp-1931429999.png mp-1941043247.png mp-1959821161.png mp-1991244469.png mp-201390378.png mp-2044448014.png mp-204754037.png mp-204847656.png mp-2097572456.png mp-2102351285.png mp-228735211.png mp-238179436.png mp-255927203.png mp-283821832.png mp-286302912.png mp-309146928.png mp-332668525.png mp-348949522.png mp-35402321.png mp-362451486.png mp-363493492.png mp-364125625.png mp-364811908.png mp-365418904.png mp-379863087.png mp-382223509.png mp-383715152.png mp-412307552.png mp-437701342.png mp-442002488.png mp-447073182.png mp-453441361.png mp-460847443.png mp-475566145.png mp-483267932.png mp-483490835.png mp-488326235.png mp-493243955.png mp-510542970.png mp-521172636.png mp-536904.png mp-537390911.png mp-541225551.png mp-548365966.png mp-551537746.png mp-556490328.png mp-568342351.png mp-568540208.png mp-574759219.png mp-584811733.png mp-608144945.png mp-611210483.png mp-618785754.png mp-628121330.png mp-633664037.png mp-666971998.png mp-719920887.png mp-720732710.png mp-727083534.png mp-760579659.png mp-764239144.png mp-774025959.png mp-774457712.png mp-788501279.png mp-795386013.png mp-813548815.png mp-827597174.png mp-830867138.png mp-834454136.png mp-836233584.png mp-847196483.png mp-859750342.png mp-860720985.png mp-869314678.png mp-872576593.png mp-874116858.png mp-875086363.png mp-899850577.png mp-912741414.png mp-922285504.png mp-960331489.png mp-968456277.png mp-983610234.png mp100655022.png mp1008474174.png mp1010834596.png mp1011038958.png mp101151070.png mp1022086164.png mp1050030194.png mp1050664105.png mp1055034640.png mp1071832204.png mp1076612750.png mp1081550755.png mp1100547827.png mp1108753066.png mp1115560970.png mp1143677372.png mp1168532045.png mp1172051623.png mp117388182.png mp1175697914.png mp1185943646.png mp1198299422.png mp121141759.png mp1218281869.png mp1253878331.png mp1254549346.png mp1257426464.png mp1258998198.png mp1263338474.png mp1265481010.png mp1279846388.png mp1281823330.png mp1289609690.png mp1309207476.png mp1309711420.png mp1312970199.png mp1317845537.png mp1319648982.png mp1328526938.png mp1343641095.png mp1345181360.png mp1350485885.png mp1354318269.png mp1354361901.png mp135580910.png mp1385229229.png mp1390160779.png mp1401799878.png mp1423623196.png mp1435068394.png mp1443545306.png mp1443731994.png mp1449616516.png mp1450877922.png mp1473941104.png mp1477969793.png mp1496195053.png mp151914586.png mp152491757.png mp1526278593.png mp1534662405.png mp1543189440.png mp1546254978.png mp155557295.png mp1556036707.png mp1563201806.png mp1573565149.png mp1578505492.png mp1587807866.png mp1587852880.png mp1592748175.png mp1597545044.png mp1602862177.png mp1618278461.png mp1618409291.png mp1630024403.png mp1632946220.png mp164189405.png mp1648574181.png mp1649050154.png mp1654814619.png mp1661155968.png mp1669391987.png mp1669536891.png mp1669826997.png mp1672815286.png mp1693494191.png mp1712397435.png mp1714558311.png mp1718257577.png mp1722757243.png mp1728259821.png mp1745580261.png mp1760247224.png mp1762961930.png mp1770684771.png mp1775755465.png mp1778115887.png mp1788981019.png mp1790906431.png mp1805450401.png mp1826205334.png mp1826210451.png mp1835534444.png mp1836669019.png mp1844645941.png mp1854264461.png mp1856770749.png mp1871597164.png mp1872455306.png mp1910338580.png mp1943577357.png mp1961464262.png mp1970682525.png mp1974890785.png mp1981984109.png mp1989380656.png mp1994180938.png mp2029183250.png mp2043548628.png mp2076672439.png mp2091786351.png mp2108883600.png mp2118997602.png mp212164494.png mp213341555.png mp213356676.png mp2135586061.png mp2136939800.png mp2139944320.png mp214566798.png mp222969924.png mp230655691.png mp247230302.png mp247336718.png mp270458285.png mp275764072.png mp286327954.png mp296250809.png mp310451968.png mp311592094.png mp312910510.png mp31685242.png mp321699752.png mp323202032.png mp324527298.png mp326310089.png mp337312116.png mp354254432.png mp372016487.png mp379987088.png mp384100282.png mp389675848.png mp390101090.png mp398283336.png mp400208748.png mp404829805.png mp414752718.png mp430366194.png mp469047465.png mp471359859.png mp493724224.png mp516580825.png mp547486137.png mp54922433.png mp55508656.png mp555532413.png mp555946742.png mp556243547.png mp56827467.png mp57382018.png mp57520205.png mp576108986.png mp579938855.png mp586783645.png mp617407028.png mp621526989.png mp664622566.png mp679843066.png mp728299919.png mp749246637.png mp757033646.png mp764546876.png mp775669060.png mp790903063.png mp805885950.png mp807348220.png mp812039471.png mp814540406.png mp822355332.png mp829045935.png mp842331717.png mp869243980.png mp905689747.png mp906124757.png mp907206848.png mp913117853.png mp932716071.png mp937256322.png mp954555337.png mp979854924.png mp994122650.png mp994357931.png
  group lvgl
    ../Core/lvgl/: ChangeLogKSDK.txt
  group lvgl/lvgl
    ../Core/lvgl/lvgl/: LICENCE.txt lvgl.h
  group lvgl/lvgl/src
    ../Core/lvgl/lvgl/src/: lv_api_map.h lv_conf_internal.h lv_conf_kconfig.h lvgl.h
  group lvgl/lvgl/src/core
    ../Core/lvgl/lvgl/src/core/: lv_disp.c lv_disp.h lv_event.c lv_event.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_indev_scroll.c lv_indev_scroll.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_draw.c lv_obj_draw.h lv_obj_pos.c lv_obj_pos.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_tree.c lv_obj_tree.h lv_refr.c lv_refr.h lv_theme.c lv_theme.h
  group lvgl/lvgl/src/draw
    ../Core/lvgl/lvgl/src/draw/: lv_draw.c lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_rect.c lv_draw_rect.h lv_draw_triangle.c lv_draw_triangle.h lv_img_buf.c lv_img_buf.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h
  group lvgl/lvgl/src/draw/nxp
    ../Core/lvgl/lvgl/src/draw/nxp/: lv_gpu_nxp.c lv_gpu_nxp.h
  group lvgl/lvgl/src/draw/nxp/pxp
    ../Core/lvgl/lvgl/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_draw_pxp_blend.h lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp.h lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp_osa.h
  group lvgl/lvgl/src/draw/nxp/vglite
    ../Core/lvgl/lvgl/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_arc.h lv_draw_vglite_blend.c lv_draw_vglite_blend.h lv_draw_vglite_rect.c lv_draw_vglite_rect.h lv_gpu_nxp_vglite.c lv_gpu_nxp_vglite.h
  group lvgl/lvgl/src/draw/sdl
    ../Core/lvgl/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl.h lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_composite.h lv_draw_sdl_img.c lv_draw_sdl_img.h lv_draw_sdl_label.c lv_draw_sdl_mask.c lv_draw_sdl_mask.h lv_draw_sdl_polygon.c lv_draw_sdl_priv.h lv_draw_sdl_rect.c lv_draw_sdl_rect.h lv_draw_sdl_stack_blur.c lv_draw_sdl_stack_blur.h lv_draw_sdl_texture_cache.c lv_draw_sdl_texture_cache.h lv_draw_sdl_utils.c lv_draw_sdl_utils.h
  group lvgl/lvgl/src/draw/stm32_dma2d
    ../Core/lvgl/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c lv_gpu_stm32_dma2d.h
  group lvgl/lvgl/src/draw/sw
    ../Core/lvgl/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw.h lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_blend.h lv_draw_sw_dither.c lv_draw_sw_dither.h lv_draw_sw_gradient.c lv_draw_sw_gradient.h lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
  group lvgl/lvgl/src/extra
    ../Core/lvgl/lvgl/src/extra/: lv_extra.c lv_extra.h
  group lvgl/lvgl/src/extra/layouts
    ../Core/lvgl/lvgl/src/extra/layouts/: lv_layouts.h
  group lvgl/lvgl/src/extra/layouts/flex
    ../Core/lvgl/lvgl/src/extra/layouts/flex/: lv_flex.c lv_flex.h
  group lvgl/lvgl/src/extra/layouts/grid
    ../Core/lvgl/lvgl/src/extra/layouts/grid/: lv_grid.c lv_grid.h
  group lvgl/lvgl/src/extra/libs
    ../Core/lvgl/lvgl/src/extra/libs/: lv_libs.h
  group lvgl/lvgl/src/extra/libs/bmp
    ../Core/lvgl/lvgl/src/extra/libs/bmp/: lv_bmp.c lv_bmp.h
  group lvgl/lvgl/src/extra/libs/ffmpeg
    ../Core/lvgl/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c lv_ffmpeg.h
  group lvgl/lvgl/src/extra/libs/freetype
    ../Core/lvgl/lvgl/src/extra/libs/freetype/: lv_freetype.c lv_freetype.h
  group lvgl/lvgl/src/extra/libs/fsdrv
    ../Core/lvgl/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c lv_fsdrv.h
  group lvgl/lvgl/src/extra/libs/gif
    ../Core/lvgl/lvgl/src/extra/libs/gif/: gifdec.c gifdec.h lv_gif.c lv_gif.h
  group lvgl/lvgl/src/extra/libs/png
    ../Core/lvgl/lvgl/src/extra/libs/png/: lodepng.c lodepng.h lv_png.c lv_png.h
  group lvgl/lvgl/src/extra/libs/qrcode
    ../Core/lvgl/lvgl/src/extra/libs/qrcode/: lv_qrcode.c lv_qrcode.h qrcodegen.c qrcodegen.h
  group lvgl/lvgl/src/extra/libs/rlottie
    ../Core/lvgl/lvgl/src/extra/libs/rlottie/: lv_rlottie.c lv_rlottie.h
  group lvgl/lvgl/src/extra/libs/sjpg
    ../Core/lvgl/lvgl/src/extra/libs/sjpg/: lv_sjpg.c lv_sjpg.h tjpgd.c tjpgd.h tjpgdcnf.h
  group lvgl/lvgl/src/extra/others
    ../Core/lvgl/lvgl/src/extra/others/: lv_others.h
  group lvgl/lvgl/src/extra/others/gridnav
    ../Core/lvgl/lvgl/src/extra/others/gridnav/: lv_gridnav.c lv_gridnav.h
  group lvgl/lvgl/src/extra/others/monkey
    ../Core/lvgl/lvgl/src/extra/others/monkey/: lv_monkey.c lv_monkey.h
  group lvgl/lvgl/src/extra/others/snapshot
    ../Core/lvgl/lvgl/src/extra/others/snapshot/: lv_snapshot.c lv_snapshot.h
  group lvgl/lvgl/src/extra/themes
    ../Core/lvgl/lvgl/src/extra/themes/: lv_themes.h
  group lvgl/lvgl/src/extra/themes/basic
    ../Core/lvgl/lvgl/src/extra/themes/basic/: lv_theme_basic.c lv_theme_basic.h
  group lvgl/lvgl/src/extra/themes/default
    ../Core/lvgl/lvgl/src/extra/themes/default/: lv_theme_default.c lv_theme_default.h
  group lvgl/lvgl/src/extra/themes/mono
    ../Core/lvgl/lvgl/src/extra/themes/mono/: lv_theme_mono.c lv_theme_mono.h
  group lvgl/lvgl/src/extra/widgets
    ../Core/lvgl/lvgl/src/extra/widgets/: lv_widgets.h
  group lvgl/lvgl/src/extra/widgets/analogclock
    ../Core/lvgl/lvgl/src/extra/widgets/analogclock/: lv_analogclock.c lv_analogclock.h
  group lvgl/lvgl/src/extra/widgets/animimg
    ../Core/lvgl/lvgl/src/extra/widgets/animimg/: lv_animimg.c lv_animimg.h
  group lvgl/lvgl/src/extra/widgets/calendar
    ../Core/lvgl/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar.h lv_calendar_header_arrow.c lv_calendar_header_arrow.h lv_calendar_header_dropdown.c lv_calendar_header_dropdown.h
  group lvgl/lvgl/src/extra/widgets/carousel
    ../Core/lvgl/lvgl/src/extra/widgets/carousel/: lv_carousel.c lv_carousel.h
  group lvgl/lvgl/src/extra/widgets/chart
    ../Core/lvgl/lvgl/src/extra/widgets/chart/: lv_chart.c lv_chart.h
  group lvgl/lvgl/src/extra/widgets/colorwheel
    ../Core/lvgl/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c lv_colorwheel.h
  group lvgl/lvgl/src/extra/widgets/dclock
    ../Core/lvgl/lvgl/src/extra/widgets/dclock/: lv_dclock.c lv_dclock.h
  group lvgl/lvgl/src/extra/widgets/imgbtn
    ../Core/lvgl/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c lv_imgbtn.h
  group lvgl/lvgl/src/extra/widgets/keyboard
    ../Core/lvgl/lvgl/src/extra/widgets/keyboard/: chinese_library.h lv_keyboard.c lv_keyboard.h lv_zh_keyboard.c lv_zh_keyboard.h
  group lvgl/lvgl/src/extra/widgets/led
    ../Core/lvgl/lvgl/src/extra/widgets/led/: lv_led.c lv_led.h
  group lvgl/lvgl/src/extra/widgets/list
    ../Core/lvgl/lvgl/src/extra/widgets/list/: lv_list.c lv_list.h
  group lvgl/lvgl/src/extra/widgets/menu
    ../Core/lvgl/lvgl/src/extra/widgets/menu/: lv_menu.c lv_menu.h
  group lvgl/lvgl/src/extra/widgets/meter
    ../Core/lvgl/lvgl/src/extra/widgets/meter/: lv_meter.c lv_meter.h
  group lvgl/lvgl/src/extra/widgets/msgbox
    ../Core/lvgl/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c lv_msgbox.h
  group lvgl/lvgl/src/extra/widgets/radiobtn
    ../Core/lvgl/lvgl/src/extra/widgets/radiobtn/: lv_radiobtn.c lv_radiobtn.h
  group lvgl/lvgl/src/extra/widgets/span
    ../Core/lvgl/lvgl/src/extra/widgets/span/: lv_span.c lv_span.h
  group lvgl/lvgl/src/extra/widgets/spinbox
    ../Core/lvgl/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c lv_spinbox.h
  group lvgl/lvgl/src/extra/widgets/spinner
    ../Core/lvgl/lvgl/src/extra/widgets/spinner/: lv_spinner.c lv_spinner.h
  group lvgl/lvgl/src/extra/widgets/tabview
    ../Core/lvgl/lvgl/src/extra/widgets/tabview/: lv_tabview.c lv_tabview.h
  group lvgl/lvgl/src/extra/widgets/tileview
    ../Core/lvgl/lvgl/src/extra/widgets/tileview/: lv_tileview.c lv_tileview.h
  group lvgl/lvgl/src/extra/widgets/win
    ../Core/lvgl/lvgl/src/extra/widgets/win/: lv_win.c lv_win.h
  group lvgl/lvgl/src/font
    ../Core/lvgl/lvgl/src/font/: lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_loader.c lv_font_loader.h lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_symbol_def.h
  group lvgl/lvgl/src/hal
    ../Core/lvgl/lvgl/src/hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group lvgl/lvgl/src/misc
    ../Core/lvgl/lvgl/src/misc/: lv_anim.c lv_anim.h lv_anim_timeline.c lv_anim_timeline.h lv_area.c lv_area.h lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_color.c lv_color.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_lru.c lv_lru.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_printf.c lv_printf.h lv_style.c lv_style.h lv_style_gen.c lv_style_gen.h lv_templ.c lv_templ.h lv_timer.c lv_timer.h lv_tlsf.c lv_tlsf.h lv_txt.c lv_txt.h lv_txt_ap.c lv_txt_ap.h lv_types.h lv_utils.c lv_utils.h
  group lvgl/lvgl/src/widgets
    ../Core/lvgl/lvgl/src/widgets/: lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnmatrix.c lv_btnmatrix.h lv_canvas.c lv_canvas.h lv_checkbox.c lv_checkbox.h lv_dropdown.c lv_dropdown.h lv_img.c lv_img.h lv_label.c lv_label.h lv_line.c lv_line.h lv_objx_templ.c lv_objx_templ.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_switch.c lv_switch.h lv_table.c lv_table.h lv_textarea.c lv_textarea.h
  group MIMXRT1176/iar
    MIMXRT1176/iar/: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf evkmimxrt1170_connect_cm4_cm7side.jlinkscript evkmimxrt1170_connect_cm7.mac
  group source
    ../Core/source/: FreeRTOSConfig.h lv_conf.h lvgl_guider.c
  group startup
    startup/: startup_MIMXRT1176_cm7.s
  group touchpanel
    ../Core/touchpanel/: fsl_gt911.c fsl_gt911.h
  group utilities
    ../Core/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_str.c fsl_str.h
  group vglite
    ../Core/vglite/: ChangeLogKSDK.txt LICENSE.txt
  group vglite/font
    ../Core/vglite/font/: buf_reader.c buf_reader.h fonts.h rle_font_read.c vft_debug.c vft_debug.h vft_draw.c vft_draw.h vg_lite_text.c
  group vglite/font/mcufont
    ../Core/vglite/font/mcufont/: LICENSE
  group vglite/font/mcufont/decoder
    ../Core/vglite/font/mcufont/decoder/: mcufont.h mf_bwfont.c mf_bwfont.h mf_config.h mf_encoding.c mf_encoding.h mf_font.c mf_font.h mf_justify.c mf_justify.h mf_kerning.c mf_kerning.h mf_rlefont.c mf_rlefont.h mf_scaledfont.c mf_scaledfont.h mf_wordwrap.c mf_wordwrap.h
  group vglite/inc
    ../Core/vglite/inc/: vg_lite.h vg_lite_hal.h vg_lite_text.h
  group vglite/VGLite
    ../Core/vglite/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c
  group vglite/VGLite/rtos
    ../Core/vglite/VGLite/rtos/: vg_lite_os.c vg_lite_os.h
  group vglite/VGLiteKernel
    ../Core/vglite/VGLiteKernel/: vg_lite_hw.h vg_lite_kernel.c vg_lite_kernel.h
  group vglite/VGLiteKernel/rtos
    ../Core/vglite/VGLiteKernel/rtos/: vg_lite_hal.c vg_lite_platform.h
  group video
    ../Core/video/: fsl_dc_fb.h fsl_dc_fb_elcdif.c fsl_dc_fb_elcdif.h fsl_dc_fb_lcdifv2.c fsl_dc_fb_lcdifv2.h fsl_display.h fsl_hx8394.c fsl_hx8394.h fsl_mipi_dsi_cmd.c fsl_mipi_dsi_cmd.h fsl_rm68191.c fsl_rm68191.h fsl_rm68200.c fsl_rm68200.h fsl_video_common.c fsl_video_common.h
  group xip
    ../Core/xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
